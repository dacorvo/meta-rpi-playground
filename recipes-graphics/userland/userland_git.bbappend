FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://rpi-userland-000-add-pkgconfig-files.patch"
